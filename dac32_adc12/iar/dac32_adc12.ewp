# IAR project dac32_adc12.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE18F512xxx16 NXP MKE18F512xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKE18F512VLL16; TWR_KE18F; TOWER; PRINTF_FLOAT_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../devices/MKE18F16/drivers; ../../../../../devices/MKE18F16; ../../../../../devices/MKE18F16/utilities/io; ../../../../../devices/MKE18F16/utilities/str; ../../../../../devices/MKE18F16/utilities/log; ../../../../../devices/MKE18F16/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: dac32_adc12.out
  ILINK.IlinkIcfFile: MKE18F512xxx16_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKE18F512VLL16; TWR_KE18F; TOWER; PRINTF_FLOAT_ENABLE=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKE18F16/drivers/: fsl_adc12.c fsl_adc12.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dac32.c fsl_dac32.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h
  group source
    ../: dac32_adc12.c
  group startup
    ../../../../../devices/MKE18F16/iar/: startup_MKE18F16.s
    ../../../../../devices/MKE18F16/: system_MKE18F16.c system_MKE18F16.h
  group utilities
    ../../../../../devices/MKE18F16/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MKE18F16/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MKE18F16/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MKE18F16/utilities/str/: fsl_str.c fsl_str.h
